#include <Types.h>
#include <Memory.h>
#include <OSUtils.h>

#include "uLibc.h"

long strlen(char * s) {
	char *sc;
	for (sc = s; *sc != '\0'; ++sc) ;
	return sc - s;
}
void memset(void *p, int c, long s) {
	while(s--)
		((char *)p)[s] = (char)c;
}
void memcpy(void* d, void* s, long z) {
	BlockMoveData(s,d,z); /* BlockMoveData ? */
}
void memmove(void* d, void* s, long z) {
	BlockMoveData(s,d,z); /* BlockMoveData ? */
}
int strcmp(char * cs,char * ct) {
	char __res;
	while (1) {
		if ((__res = *cs - *ct++) != 0 || !*cs++)
			break;
	}
	return __res;
}
char * strcat(char * dest, char * src) {
	char *tmp = dest;
	while (*dest) dest++;
	while ((*dest++ = *src++) != '\0') ;
	return tmp;
}
void strcpy(char * dest, char * src) {
	BlockMoveData(src, dest, strlen(src)+1);
}

int strncmp(char * cs,char * ct,long count) {
	char __res = 0;
	while (count) {
		if ((__res = *cs - *ct++) != 0 || !*cs++)
			break;
		count--;
	}
	return __res;
}


